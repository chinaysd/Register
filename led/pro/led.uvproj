# Keil uVision project led.uvproj, settings and files
target led (MCS-51)
  device: SC92F7321 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(24000000)
  output: led +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\bsp;..\lib;..\TimeOut;..\user
  group startup
    ./: STARTUP.A51
  group user
    ../user/: main.c system.c
  group bsp
    ../bsp/: bsp_led.c bsp_timer.c
    ../TimeOut/: TimeOut.c
  group lib
    ../lib/: SC92F732X_C.H
